# Keil uVision project gpio_2_lib.uvproj, settings and files
target gpio2_lib (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: gpio_2_lib +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: G:\강의자료\ARM\lecture\Header_all;G:\강의자료\ARM\lecture\Header_all\STM3210B_EVAL;..\gpio2_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../gpio2_lib/: main.c stm32f10x_it.c system_stm32f10x.c
  group lib
    ../Objects/: stm_lib.lib
